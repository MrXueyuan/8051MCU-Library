# Keil uVision project 6050Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 6050Test +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 例程2.c
